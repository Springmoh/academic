options:
  parameters:
    generate_options: qt_gui
    id: pm_demodulator
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: f_car
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: kp
  id: variable
  parameters:
    value: '4.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-f_car'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/mohnc/Downloads/P_comm Assignment/PM/modulation/pm_modulator.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/kp
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: ff
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self):
              gr.sync_block.__init__(
                  self,
                  name="phase_unwrap",
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.prev = 0.0
              self.offset = 0.0

          def work(self, input_items, output_items):
              x = input_items[0]
              y = output_items[0]

              for i, p in enumerate(x):
                  dp = p - self.prev
                  if dp > np.pi:
                      self.offset -= 2*np.pi
                  elif dp < -np.pi:
                      self.offset += 2*np.pi
                  y[i] = p + self.offset
                  self.prev = p

              return len(y)
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '2000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '500'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    name: '"Demodulation SIgnal"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [blocks_complex_to_arg_0, '0', epy_block_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_throttle2_0, '0', blocks_multiply_xx_0, '0']
- [dc_blocker_xx_0, '0', qtgui_time_sink_x_0, '0']
- [epy_block_0, '0', blocks_multiply_const_vxx_0, '0']
- [low_pass_filter_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
